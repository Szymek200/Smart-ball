## sensors_testing/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_ENABLE_BACKWARD_COMPATIBILITY=y
CONFIG_AUDIO_BOARD_CUSTOM=y
CONFIG_ESP_LYRAT_V4_3_BOARD=n
```
